# Keil uVision project rt1064-local.uvprojx, settings and files
target nor_sdram_zf_dtcm (6210000::V6.21::ARMCLANG)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.25.09.00
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x70000000,0x400000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt1064
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_MIMXRT1064DVL6A,SKIP_SYSCLK_INIT,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_DCD_ENABLE =1, XIP_BOOT_HEADER_ENABLE =1,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1, FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0, USB_STACK_BM, DEBUG, MCUXPRESSO_SDK, SD_ENABLED
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb -Wno-invalid-source-encoding
  c include: C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\demo\user\inc;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\demo\code;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\sdk\startup\mdk;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\sdk\deceive;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\sdk\drives;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\sdk\xip;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\sdk\utilities;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\sdk\utilities\debug_console;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\sdk\utilities\str;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\sdk\cmsis_drivers;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\sdk\CMSIS\Include;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\sdk\CMSIS\Driver\Include;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\sdk\components\lists;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\sdk\components\osa;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\sdk\components\serial_manager;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\sdk\components\uart;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\sdk\board;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\components\fatfs\source;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\components\fatfs\source\fsl_sd_disk;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\components\sdmmc;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\components\sdmmc\common;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\components\sdmmc\host\usdhc;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\components\sdmmc\osa;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\components\sdmmc\sd;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\components\usb\device;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\components\usb\include;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\components\usb\phy;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\components\usb\usb_cdc_adapter;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\zf_common;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\zf_driver;C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\libraries\zf_device
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: C:\Users\21591\Downloads\Wedontcar-Vision-Control-1101-yubao\Wedontcar-Vision-Control-1101-yubao\demo\mdk\scf\MIMXRT1064xxxxx_flexspi_nor.scf
  link misc: --remove --entry=Reset_Handler
  group user_c
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/demo/user/src/: isr.c main.c img_process.c pid.c track_vision.c track_control.c imu_navigation.c ring_control.c ring_corner.c
  group user_h
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/demo/user/inc/: isr.h
  group doc
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/libraries/doc/: GPL3_permission_statement.txt read me.txt version.txt
  group zf_common
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/libraries/zf_common/: zf_common_clock.c zf_common_clock.h zf_common_debug.c zf_common_debug.h zf_common_fifo.c zf_common_fifo.h zf_common_font.c zf_common_font.h zf_common_function.c zf_common_function.h zf_common_headfile.h zf_common_interrupt.c zf_common_interrupt.h zf_common_typedef.h zf_common_vector.c zf_common_vector.h
  group zf_driver
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/libraries/zf_driver/: zf_driver_adc.c zf_driver_adc.h zf_driver_csi.c zf_driver_csi.h zf_driver_delay.c zf_driver_delay.h zf_driver_encoder.c zf_driver_encoder.h zf_driver_exti.c zf_driver_exti.h zf_driver_flash.c zf_driver_flash.h zf_driver_flexio_csi.c zf_driver_flexio_csi.h zf_driver_gpio.c zf_driver_gpio.h zf_driver_iic.c zf_driver_iic.h zf_driver_pit.c zf_driver_pit.h zf_driver_pwm.c zf_driver_pwm.h zf_driver_romapi.c zf_driver_romapi.h zf_driver_sdio.c zf_driver_sdio.h zf_driver_soft_iic.c zf_driver_soft_iic.h zf_driver_soft_spi.c zf_driver_soft_spi.h zf_driver_spi.c zf_driver_spi.h zf_driver_timer.c zf_driver_timer.h zf_driver_uart.c zf_driver_uart.h zf_driver_usb_cdc.c zf_driver_usb_cdc.h
  group zf_device
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/libraries/zf_device/: zf_device_absolute_encoder.c zf_device_absolute_encoder.h zf_device_bluetooth_ch9141.c zf_device_bluetooth_ch9141.h zf_device_camera.c zf_device_camera.h zf_device_gps_tau1201.c zf_device_gps_tau1201.h zf_device_icm20602.c zf_device_icm20602.h zf_device_imu963ra.c zf_device_imu963ra.h zf_device_imu660ra.c zf_device_imu660ra.h zf_device_imu660rb.c zf_device_imu660rb.h zf_device_ips114.c zf_device_ips114.h zf_device_ips200.c zf_device_ips200.h zf_device_key.c zf_device_key.h zf_device_mpu6050.c zf_device_mpu6050.h zf_device_mt9v03x.c zf_device_mt9v03x.h zf_device_mt9v03x_flexio.c zf_device_mt9v03x_flexio.h zf_device_oled.c zf_device_oled.h zf_device_ov7725.c zf_device_ov7725.h zf_device_scc8660.c zf_device_scc8660.h zf_device_scc8660_flexio.c zf_device_scc8660_flexio.h zf_device_tft180.c zf_device_tft180.h zf_device_tsl1401.c zf_device_tsl1401.h zf_device_type.c zf_device_type.h zf_device_virtual_oscilloscope.c zf_device_virtual_oscilloscope.h zf_device_wifi_uart.c zf_device_wifi_uart.h zf_device_wireless_uart.c zf_device_wireless_uart.h zf_device_config.h zf_device_config.lib zf_device_detector.c zf_device_detector.h zf_device_dl1a.c zf_device_dl1a.h zf_device_dl1b.c zf_device_dl1b.h zf_device_wifi_spi.c zf_device_wifi_spi.h
  group sdk_drivers
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/libraries/sdk/drives/: fsl_adc.c fsl_adc.h fsl_adc_etc.c fsl_adc_etc.h fsl_aipstz.c fsl_aipstz.h fsl_aoi.c fsl_aoi.h fsl_bee.c fsl_bee.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_csi.c fsl_csi.h fsl_dcdc.c fsl_dcdc.h fsl_dcp.c fsl_dcp.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_elcdif.c fsl_elcdif.h fsl_enc.c fsl_enc.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flexcan.c fsl_flexcan.h fsl_flexcan_edma.c fsl_flexcan_edma.h fsl_flexio.c fsl_flexio.h fsl_flexio_camera.c fsl_flexio_camera.h fsl_flexio_camera_edma.c fsl_flexio_camera_edma.h fsl_flexio_i2c_master.c fsl_flexio_i2c_master.h fsl_flexio_i2s.c fsl_flexio_i2s.h fsl_flexio_i2s_edma.c fsl_flexio_i2s_edma.h fsl_flexio_mculcd.c fsl_flexio_mculcd.h fsl_flexio_mculcd_edma.c fsl_flexio_mculcd_edma.h fsl_flexio_spi.c fsl_flexio_spi.h fsl_flexio_spi_edma.c fsl_flexio_spi_edma.h fsl_flexio_uart.c fsl_flexio_uart.h fsl_flexio_uart_edma.c fsl_flexio_uart_edma.h fsl_flexram.c fsl_flexram.h fsl_flexram_allocate.c fsl_flexram_allocate.h fsl_flexspi.c fsl_flexspi.h fsl_gpc.c fsl_gpc.h fsl_gpio.c fsl_gpio.h fsl_gpt.c fsl_gpt.h fsl_iomuxc.h fsl_kpp.c fsl_kpp.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpi2c_edma.c fsl_lpi2c_edma.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.c fsl_lpspi_edma.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_ocotp.c fsl_ocotp.h fsl_pit.c fsl_pit.h fsl_pmu.c fsl_pmu.h fsl_pwm.c fsl_pwm.h fsl_pxp.c fsl_pxp.h fsl_qtmr.c fsl_qtmr.h fsl_rtwdog.c fsl_rtwdog.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_semc.c fsl_semc.h fsl_snvs_hp.c fsl_snvs_hp.h fsl_snvs_lp.c fsl_snvs_lp.h fsl_spdif.c fsl_spdif.h fsl_spdif_edma.c fsl_spdif_edma.h fsl_src.c fsl_src.h fsl_tempmon.c fsl_tempmon.h fsl_trng.c fsl_trng.h fsl_tsc.c fsl_tsc.h fsl_usdhc.c fsl_usdhc.h fsl_wdog.c fsl_wdog.h fsl_xbara.c fsl_xbara.h fsl_xbarb.c fsl_xbarb.h
  group sdk_device
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/libraries/sdk/board/: board.c board.h clock_config.c clock_config.h
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/libraries/sdk/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c evkmimxrt1064_sdram_ini_dcd.h evkmimxrt1064_sdram_ini_dcd.c evkmimxrt1064_flexspi_nor_config.h evkmimxrt1064_flexspi_nor_config.c
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/libraries/sdk/deceive/: system_MIMXRT1064.h system_MIMXRT1064.c MIMXRT1064_features.h MIMXRT1064.h fsl_device_registers.h
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/libraries/sdk/startup/mdk/: startup_MIMXRT1064.S
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/libraries/sdk/utilities/: fsl_assert.c
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/libraries/sdk/components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/libraries/sdk/components/lists/: fsl_component_generic_list.c
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/libraries/sdk/components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/libraries/sdk/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group components_fatfs
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/libraries/components/fatfs/source/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/libraries/components/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group components_sdmmc
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/libraries/components/sdmmc/: sdmmc_config.c sdmmc_config.h
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/libraries/components/sdmmc/common/: fsl_sdmmc_common.c fsl_sdmmc_common.h fsl_sdmmc_spec.h
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/libraries/components/sdmmc/host/usdhc/: fsl_sdmmc_host.h
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/libraries/components/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/libraries/components/sdmmc/osa/: fsl_sdmmc_osa.c fsl_sdmmc_osa.h
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/libraries/components/sdmmc/sd/: fsl_sd.c fsl_sd.h
  group components_usb
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/libraries/components/usb/device/: usb_device_ehci.c usb_device_ehci.h usb_device_dci.c usb_device_dci.h usb_device.h
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/libraries/components/usb/include/: usb.h usb_misc.h usb_spec.h
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/libraries/components/usb/phy/: usb_phy.c usb_phy.h
    C:/Users/21591/Downloads/Wedontcar-Vision-Control-1101-yubao/Wedontcar-Vision-Control-1101-yubao/libraries/components/usb/usb_cdc_adapter/: usb_device_cdc_acm.c usb_device_cdc_acm.h usb_device_ch9.c usb_device_ch9.h usb_device_class.c usb_device_class.h usb_device_config.h usb_device_descriptor.c usb_device_descriptor.h
